# Keil uVision project SPI-TFT_Test.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI-TFT_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\SPI-TFT_Test.sct
  group Source Group 1
    ./: BIT_MATH.h GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c RCC_config.h RCC_interface.h RCC_private.h RCC_program.c SPI_config.h SPI_interface.h SPI_private.h SPI_program.c STD_TYPES.h STK_config.h STK_interface.h STK_private.h STK_program.c TFT_config.h TFT_interface.h TFT_private.h TFT_program.c main.c image.h
software components: CMSIS:CORE 5.6.0, Device:DMA 1.3, Device:Startup 1.0.0
